# IAR project TelescopeController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ; Utilities\STM32F4-Discovery; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries\STM32_USB_OTG_Driver\inc; Libraries\STM32_USB_Device_Library\Class\cdc\inc; Libraries\STM32_USB_Device_Library\Core\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TelescopeController.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32_USB_Device_Library/Class/cdc
    Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32_USB_Device_Library/Core
    Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F4-Discovery
    Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../IAR Embedded Workbench/ARM/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ./: commands.c keypad.c main.c remote_control.c stm32f4xx_it.c system_stm32f4xx.c system_time.c telescope_control.c timers.c usb_bsp.c usbd_desc.c usbd_usr.c utils.c
